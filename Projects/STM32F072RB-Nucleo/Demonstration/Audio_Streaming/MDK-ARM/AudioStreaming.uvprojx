# Keil uVision project AudioStreaming.uvprojx, settings and files
target STM32F072-SOUNDTER1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: AudioStreaming_F0 +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_STM32F0XX_NUCLEO,USE_HAL_DRIVER,USE_HAL_LEGACY
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F0xx_Nucleo;../../../../../Drivers/BSP/CCA01M1;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/STM32_Audio/Addons/BiquadCalculator;../../../../../Drivers/BSP/Components/sta350bw;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: audio_application.c cube_hal_f0.c main.c nucleo_f072rb_bus.c stm32xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F0xx_Nucleo
    ../../../../../Drivers/BSP/STM32F0xx_Nucleo/: stm32f0xx_nucleo.c
  group Drivers/BSP/CCA01M1
    ../../../../../Drivers/BSP/CCA01M1/: cca01m1_audio.c cca01m1_audio_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/Components
    ../../../../../Drivers/BSP/Components/sta350bw/: sta350bw.c sta350bw_reg.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_ll_usb.c
  group Middlewares/ST/STM32_Audio/Biquad Calculator
    ../../../../../Middlewares/ST/STM32_Audio/Addons/BiquadCalculator/: BiquadCalculator.c BiquadPresets.c
software components: CMSIS:CORE 4.3.0
