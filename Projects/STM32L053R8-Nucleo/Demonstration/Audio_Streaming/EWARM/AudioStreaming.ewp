# IAR project AudioStreaming.ewp, settings and files
configuration STM32L053-SOUNDTER1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\Inc; ..\..\..\..\..\Drivers\BSP\CCA01M1; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\BiquadCalculator; ..\..\..\..\..\Drivers\BSP\Components\sta350bw; ..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AudioStreaming_L0.bin
  ILINK.IlinkOutputFile: STM32L053R8_SOUNDTER.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: audio_application.c cube_hal_l0.c main.c nucleo_l053r8_bus.c stm32xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/sta350bw/: sta350bw.c sta350bw_reg.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/CCA01M1
    ../../../../../Drivers/BSP/CCA01M1/: cca01m1_audio.c cca01m1_audio_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Middlewares/STM32_Audio/Biquad Calculator
    ../../../../../Middlewares/ST/STM32_Audio/Addons/BiquadCalculator/: BiquadCalculator.c BiquadPresets.c
