# Keil uVision project AudioStreaming.uvprojx, settings and files
target STM32L476-SOUNDTER1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476-SOUNDTER1 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,USE_USB_FS,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\Drivers\BSP\CCA01M1;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\BiquadCalculator;..\..\..\..\..\Drivers\BSP\Components\sta350bw;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: audio_application.c main.c stm32xx_it.c cube_hal_l4.c nucleo_l476rg_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/CCA01M1
    ../../../../../Drivers/BSP/CCA01M1/: cca01m1_audio.c cca01m1_audio_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Middlewares/ST/STM32_Audio/Biq Calc
    ../../../../../Middlewares/ST/STM32_Audio/Addons/BiquadCalculator/: BiquadCalculator.c BiquadPresets.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/sta350bw/: sta350bw.c sta350bw_reg.c
